<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Apr 23 18:47:43 2026</timestamp>
			<uuid>{323ad9fc-787a-4eab-b04e-081c7d596864}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.0</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.0</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.1
			<timestamp>Apr 23 18:48:26 2026</timestamp>
			<uuid>{3da77023-07d5-44b1-9813-cdbc3d3a01d4}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.1</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.1</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.2
			<timestamp>Apr 23 18:48:56 2026</timestamp>
			<uuid>{ade2a7b3-b25d-4b1c-87cc-0aba041162cb}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.2</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.2</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.3
			<timestamp>Apr 23 18:50:20 2026</timestamp>
			<uuid>{515df02f-d91b-4f71-ad3c-fe36ff293b2a}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.3</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.3</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.4
			<timestamp>Apr 23 18:51:10 2026</timestamp>
			<uuid>{aa8a1945-7fc3-46e5-a38d-3a292876129a}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.4</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.4</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.5
			<timestamp>Apr 23 18:52:12 2026</timestamp>
			<uuid>{86f77eb0-f746-4761-960a-cbb8ee9982ae}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.5</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.5</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.6
			<timestamp>Apr 23 18:53:43 2026</timestamp>
			<uuid>{1ab9d4a9-8c86-40b8-b54f-89aecf8afda1}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.6</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.6</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.7
			<timestamp>Apr 23 18:54:40 2026</timestamp>
			<uuid>{ba7e4a90-c554-4735-a887-2240354653bd}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.7</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.7</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.8
			<timestamp>Apr 23 18:56:13 2026</timestamp>
			<uuid>{462a21ce-a9c4-471a-8057-c3c8f8d8b396}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.8</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.8</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.9
			<timestamp>Apr 23 18:56:40 2026</timestamp>
			<uuid>{32bbdb44-7171-4631-8245-ca45d458250a}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.9</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.9</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.10
			<timestamp>Apr 23 18:58:03 2026</timestamp>
			<uuid>{6354374c-dfa8-4e94-9e81-6af3e7a171ec}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.10</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.10</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.11
			<timestamp>Apr 23 18:58:50 2026</timestamp>
			<uuid>{e89e1c10-98a7-40a7-b39d-49b7e03e7ab2}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.11</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.11</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.12
			<timestamp>Apr 23 19:00:07 2026</timestamp>
			<uuid>{738db94f-ab63-4993-964f-6c957b406c1e}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.12</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.12</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.13
			<timestamp>Apr 23 19:05:47 2026</timestamp>
			<uuid>{8ac16bff-9bf1-421c-ab20-d75667c0bdac}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.13</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.13</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.14
			<timestamp>Apr 23 19:08:24 2026</timestamp>
			<uuid>{cfc047dd-8a61-43de-97ee-950f2dfd13c8}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.14</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.14</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.15
			<timestamp>Apr 23 19:11:16 2026</timestamp>
			<uuid>{468f585e-3898-414b-8a91-bfdb8acde593}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.15</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.15</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.16
			<timestamp>Apr 23 19:11:52 2026</timestamp>
			<uuid>{58cdd3f7-61dd-4e06-be21-b5f91aa81034}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.16</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.16</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.17
			<timestamp>Apr 23 19:12:42 2026</timestamp>
			<uuid>{3620bfe7-a5c5-4828-8d4d-f604a8ebd3e6}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.17</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.17</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.18
			<timestamp>Apr 23 19:17:07 2026</timestamp>
			<uuid>{e58443c0-d542-48f9-847a-a540e46a3a03}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.18</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.18</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.19
			<timestamp>Apr 23 20:16:19 2026</timestamp>
			<uuid>{c87a193e-3f9a-4f66-bc82-2e9308d0a7ff}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.19</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.19</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.20
			<timestamp>Apr 23 20:17:05 2026</timestamp>
			<uuid>{b5b8cd26-bc85-418a-8aa7-4b8f2397f7db}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.20</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.20</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.21
			<timestamp>Apr 23 20:28:01 2026</timestamp>
			<uuid>{12a9995b-cd67-484e-9ef6-624127a17f5a}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.21</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.21</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.22
			<timestamp>Apr 23 20:34:46 2026</timestamp>
			<uuid>{b7e4c292-c41a-403b-af3f-ca2dfb2d2d83}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.22</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.22</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.23
			<timestamp>Apr 23 20:36:24 2026</timestamp>
			<uuid>{296d7a20-38d5-49b6-bfc5-953a650fbcbf}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.23</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.23</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.24
			<timestamp>Apr 23 20:36:57 2026</timestamp>
			<uuid>{6d6b09ad-7d34-49ed-8f63-78efa8f09bbc}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.24</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.24</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.25
			<timestamp>Apr 23 20:37:34 2026</timestamp>
			<uuid>{ee5ade45-cb33-4490-b2d7-783c4f3ded88}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.25</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.25</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.26
			<timestamp>Apr 23 20:39:13 2026</timestamp>
			<uuid>{a407bac0-0832-47f4-a903-b32bc6e6454e}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.26</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.26</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.27
			<timestamp>Apr 23 20:45:15 2026</timestamp>
			<uuid>{cb0bb085-2a49-4442-bb3f-a9502537c77e}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.27</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.27</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.28
			<timestamp>Apr 24 11:20:17 2026</timestamp>
			<uuid>{8d98dced-7c03-4be3-8f6e-fd8cc9f61030}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.28</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.28</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.29
			<timestamp>Apr 24 14:45:04 2026</timestamp>
			<uuid>{c5163fba-705d-4a94-8dc2-0d06cdb55695}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.29</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.29</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.30
			<timestamp>Apr 24 18:10:02 2026</timestamp>
			<uuid>{599fa647-0e80-4a11-b01f-51f2ce110938}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.30</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.30</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.31
			<timestamp>Apr 24 18:12:21 2026</timestamp>
			<uuid>{bf9bfba6-cb8a-49af-86f9-84dc4bb737ba}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.31</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.31</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.32
			<timestamp>Apr 24 18:41:40 2026</timestamp>
			<uuid>{4e7bde0b-6891-44c0-897e-1ca405f8c0a0}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.32</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.32</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.33
			<timestamp>Apr 24 18:45:48 2026</timestamp>
			<uuid>{1715ccdd-57db-4b69-a495-175f78864db0}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.33</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.33</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.34
			<timestamp>Apr 24 22:16:57 2026</timestamp>
			<uuid>{d602cf67-b1bf-4391-b624-7bdc744c1d2e}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.34</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.34</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.35
			<timestamp>Apr 25 08:50:09 2026</timestamp>
			<uuid>{bbb7bbb0-33bf-4bd8-b548-89f5e6c4eb50}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.35</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.35</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.36
			<timestamp>Apr 25 11:48:46 2026</timestamp>
			<uuid>{d8639aa1-814d-4998-a9cb-97c33d0d39f1}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.36</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.36</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.37
			<timestamp>Apr 25 14:20:50 2026</timestamp>
			<uuid>{9d6ce4aa-9b8d-493a-a2a4-e3720e4f8a67}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.37</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.37</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.38
			<timestamp>Apr 25 14:22:39 2026</timestamp>
			<uuid>{57b1764e-3962-4128-ba2a-a5ab19e0724f}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.38</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.38</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.39
			<timestamp>Apr 25 14:29:09 2026</timestamp>
			<uuid>{50f55c7c-ad45-4a5e-868a-86761f1ed2c5}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.39</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.39</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.40
			<timestamp>Apr 25 14:30:51 2026</timestamp>
			<uuid>{d08981e7-244b-4f06-8e12-ba95910083d3}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.40</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.40</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.41
			<timestamp>Apr 25 14:32:53 2026</timestamp>
			<uuid>{33fabdd5-ef96-4fe4-9c05-452242fb3350}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.41</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.41</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.42
			<timestamp>Apr 25 14:41:04 2026</timestamp>
			<uuid>{82731675-4859-4c10-b6ff-1a48a98f3e64}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.42</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.42</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.43
			<timestamp>Apr 25 14:48:29 2026</timestamp>
			<uuid>{14c1fd5d-85d2-4015-aeb2-e2dff94cbe90}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.43</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.43</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.44
			<timestamp>Apr 25 14:49:39 2026</timestamp>
			<uuid>{8103b4e3-76b8-4b8c-9752-9d5fa4d81338}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.44</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.44</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.45
			<timestamp>Apr 25 14:50:47 2026</timestamp>
			<uuid>{20200c14-81df-4967-bd18-d9a90294c2a6}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.45</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.45</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.46
			<timestamp>Apr 25 14:55:12 2026</timestamp>
			<uuid>{7f5a7c6a-cb0d-4c4c-a4c5-2ebcc824a581}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.46</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.46</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.47
			<timestamp>Apr 25 15:08:32 2026</timestamp>
			<uuid>{ec409a6d-a600-48b8-b1f2-ade9c55d8776}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.47</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.47</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.48
			<timestamp>Apr 25 15:09:25 2026</timestamp>
			<uuid>{ff2b069f-db57-43c8-a0d1-b5bdf366263d}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.48</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.48</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.49
			<timestamp>Apr 25 15:10:11 2026</timestamp>
			<uuid>{2682c8fd-baff-48fd-8762-032b7b45417b}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.49</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.49</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.50
			<timestamp>Apr 25 15:11:22 2026</timestamp>
			<uuid>{4b3cb54c-4d84-4eb7-bcff-046a36fff0f0}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.50</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.50</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.51
			<timestamp>Apr 25 15:12:42 2026</timestamp>
			<uuid>{7845a14f-2ad3-4a72-8d9a-b5f3ac8d5f23}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.51</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.51</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.52
			<timestamp>Apr 25 15:14:00 2026</timestamp>
			<uuid>{dbdad736-c865-4cea-b5b4-a556135d6982}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.52</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.52</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.53
			<timestamp>Apr 25 15:15:34 2026</timestamp>
			<uuid>{7fd289b8-d0d7-42de-bc40-3a66db25b551}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.53</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.53</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.54
			<timestamp>Apr 25 15:23:20 2026</timestamp>
			<uuid>{0fb45f8c-7159-4dee-8801-10b9a6bc9889}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.54</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.54</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.55
			<timestamp>Apr 25 15:23:54 2026</timestamp>
			<uuid>{625cf9a0-a510-4f0e-88d6-ffc37b2bbe9e}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.55</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.55</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.56
			<timestamp>Apr 25 15:26:21 2026</timestamp>
			<uuid>{59c77f13-ffc5-46f5-99c0-1eed605da399}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.56</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.56</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.57
			<timestamp>Apr 25 15:27:28 2026</timestamp>
			<uuid>{4b8898d5-62df-4cce-934e-bc7bb6b75a27}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.57</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.57</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.58
			<timestamp>Apr 25 15:28:05 2026</timestamp>
			<uuid>{00604dc0-96e6-4755-b9b9-7bcc6e87367d}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.58</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.58</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.59
			<timestamp>Apr 25 15:30:00 2026</timestamp>
			<uuid>{c26ee932-aa2a-4023-aeae-405d294c33ac}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.59</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.59</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.60
			<timestamp>Apr 25 15:30:52 2026</timestamp>
			<uuid>{f06d0627-4381-4fad-9360-e0d75bdd2785}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.60</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.60</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.61
			<timestamp>Apr 25 16:17:16 2026</timestamp>
			<uuid>{c4487713-5312-4b4f-a3c0-ad5020fecc95}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.61</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.61</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.62
			<timestamp>Apr 25 16:17:59 2026</timestamp>
			<uuid>{26392b65-2052-4dcd-aaa4-af774937568d}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.62</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.62</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.63
			<timestamp>Apr 25 16:19:03 2026</timestamp>
			<uuid>{00bf30bf-f8d6-4750-94ec-34a53e35be97}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.63</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.63</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.64
			<timestamp>Apr 25 16:21:15 2026</timestamp>
			<uuid>{d5cee3e7-8761-4ee3-8e28-011d915e1362}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.64</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.64</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.65
			<timestamp>Apr 25 16:24:15 2026</timestamp>
			<uuid>{56d2c521-899c-4968-97d0-37bdbda29f5d}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.65</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.65</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.66
			<timestamp>Apr 25 16:29:13 2026</timestamp>
			<uuid>{acc79ce2-3e6f-4158-b6ca-3d69bda4b573}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.66</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.66</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.67
			<timestamp>Apr 25 16:30:02 2026</timestamp>
			<uuid>{64d10ec3-c066-4312-8e3f-4e0a76383ff0}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.67</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.67</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.68
			<timestamp>Apr 25 16:31:14 2026</timestamp>
			<uuid>{17ac055f-0b39-4f12-bfa9-2f1c4fbcad6e}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.68</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.68</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.69
			<timestamp>Apr 25 16:32:27 2026</timestamp>
			<uuid>{69dbae48-3528-4e00-a09a-b469b513ed34}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.69</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.69</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.70
			<timestamp>Apr 25 16:34:16 2026</timestamp>
			<uuid>{9c390342-fa30-4a74-982f-6a049264ab27}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.70</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.70</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.71
			<timestamp>Apr 25 16:35:29 2026</timestamp>
			<uuid>{bd1d47ac-71ca-4f29-a3bc-c4fb52a4c673}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.71</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.71</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.72
			<timestamp>Apr 25 16:36:07 2026</timestamp>
			<uuid>{c9399f79-a538-4970-93db-a59462bc3636}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.72</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.72</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.73
			<timestamp>Apr 25 16:36:41 2026</timestamp>
			<uuid>{0723ea99-6bd4-461c-9b4c-914a82349447}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.73</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.73</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.74
			<timestamp>Apr 25 16:37:14 2026</timestamp>
			<uuid>{eedd1540-6d32-4239-8a71-8e960ea22d2d}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.74</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.74</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.75
			<timestamp>Apr 25 16:54:08 2026</timestamp>
			<uuid>{eeaf3666-ce99-42bf-beb6-de54330c2822}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.75</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.75</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.76
			<timestamp>Apr 25 16:54:42 2026</timestamp>
			<uuid>{524103f4-cc3d-4763-af54-2747dd516b32}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.76</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.76</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.77
			<timestamp>Apr 25 16:55:26 2026</timestamp>
			<uuid>{5981bf31-65fd-4049-95fc-cb1dc467a7c1}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.77</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.77</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.78
			<timestamp>Apr 25 16:57:57 2026</timestamp>
			<uuid>{62519815-d98c-4736-9b56-8cbe58fb877d}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.78</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.78</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.79
			<timestamp>Apr 25 16:58:57 2026</timestamp>
			<uuid>{81392a5a-0725-462d-b22e-214c3e3598d8}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.79</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.79</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.80
			<timestamp>Apr 25 16:59:51 2026</timestamp>
			<uuid>{e7001d9b-f245-4b51-8e62-530f770c9fac}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.80</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.80</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.81
			<timestamp>Apr 25 17:00:18 2026</timestamp>
			<uuid>{3c6da7f2-221e-463b-9216-7a0123974de3}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.81</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.81</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.82
			<timestamp>Apr 25 18:28:44 2026</timestamp>
			<uuid>{2501c605-69de-42bb-a734-a1f0ef650f45}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.82</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.82</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.83
			<timestamp>Apr 25 18:55:21 2026</timestamp>
			<uuid>{34950e76-5e44-4fee-b37b-175191d5c4db}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.83</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.83</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.84
			<timestamp>Apr 25 18:55:50 2026</timestamp>
			<uuid>{50349099-0ce4-4eba-90e1-12d65d971d89}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.84</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.84</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.85
			<timestamp>Apr 25 18:56:20 2026</timestamp>
			<uuid>{e49170f6-e61d-40a4-8107-0513f5e3ab2c}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.85</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.85</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.86
			<timestamp>Apr 25 18:56:53 2026</timestamp>
			<uuid>{7b98727d-9e60-4541-bd7b-6370d0912abc}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.86</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.86</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.87
			<timestamp>Apr 25 18:57:21 2026</timestamp>
			<uuid>{da329e27-0cfd-4ee5-a949-40b3a19bb996}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.87</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.87</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.88
			<timestamp>Apr 25 19:00:42 2026</timestamp>
			<uuid>{32149cd9-980d-482b-a00f-6be3fde6b891}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.88</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.88</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.89
			<timestamp>Apr 25 19:01:26 2026</timestamp>
			<uuid>{a7a761da-07d0-4db0-9ffe-ffd75e8e270d}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.89</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.89</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.90
			<timestamp>Apr 25 19:02:23 2026</timestamp>
			<uuid>{c5de787b-096c-4c5b-a1a3-a9fdfdf690d0}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.90</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.90</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.91
			<timestamp>Apr 25 19:03:22 2026</timestamp>
			<uuid>{c080f3b3-6dce-4be6-97f1-35cd91002f8c}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.91</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.91</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.92
			<timestamp>Apr 25 19:06:49 2026</timestamp>
			<uuid>{ffd7ea26-45fb-4f71-af76-a6cbaf010a2e}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.92</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.92</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.93
			<timestamp>Apr 25 19:07:31 2026</timestamp>
			<uuid>{a781ce6b-a3eb-4566-bf68-23e7241e45e0}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.93</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.93</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.94
			<timestamp>Apr 25 19:07:59 2026</timestamp>
			<uuid>{b499f761-4837-405f-9432-a2b907a45dc0}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.94</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.94</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.95
			<timestamp>Apr 25 19:08:32 2026</timestamp>
			<uuid>{7e05e021-f236-4be3-895b-50ccccf30082}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.95</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.95</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.96
			<timestamp>Apr 25 19:09:53 2026</timestamp>
			<uuid>{948ebc6c-f5d9-46c3-896b-f296c6af7ce1}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.96</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.96</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.97
			<timestamp>Apr 25 19:10:39 2026</timestamp>
			<uuid>{ce19dd29-959e-4185-ba50-b86137542444}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.97</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.97</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.98
			<timestamp>Apr 25 19:11:11 2026</timestamp>
			<uuid>{26ca21e5-0f54-430a-98e8-5385bfa847e7}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.98</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.98</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.99
			<timestamp>Apr 25 19:11:35 2026</timestamp>
			<uuid>{0625fb16-c491-4446-9de4-d3883c14b37d}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.99</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.99</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.100
			<timestamp>Apr 25 19:12:17 2026</timestamp>
			<uuid>{853b8a53-bda8-478e-be1f-39b7623fce54}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.100</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.100</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.101
			<timestamp>Apr 25 19:13:12 2026</timestamp>
			<uuid>{d7fd87dc-cbff-460d-b515-e481a0b74670}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.101</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.101</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.102
			<timestamp>Apr 25 19:13:41 2026</timestamp>
			<uuid>{a945e92f-467b-4bce-b2cb-1469917b6426}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.102</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.102</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.103
			<timestamp>Apr 25 19:14:13 2026</timestamp>
			<uuid>{9444e9bd-219b-4c5b-8c8b-a9d40cbe048a}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.103</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.103</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.104
			<timestamp>Apr 25 19:15:01 2026</timestamp>
			<uuid>{093e5f07-b637-4ebc-bd98-69b790847102}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.104</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.104</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.105
			<timestamp>Apr 25 19:15:52 2026</timestamp>
			<uuid>{062fc4a2-1fa8-4209-92b8-7353a9c8b600}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.105</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.105</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.106
			<timestamp>Apr 25 19:16:53 2026</timestamp>
			<uuid>{930241d7-cc72-462e-b3aa-c866b9bc838f}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.106</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.106</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.107
			<timestamp>Apr 25 19:17:43 2026</timestamp>
			<uuid>{045cca14-e4e2-419d-966d-a0517dbfb8ff}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.107</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.107</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.108
			<timestamp>Apr 25 19:18:48 2026</timestamp>
			<uuid>{259d3005-aa7a-4b5c-8a78-67d8c49ab33b}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.108</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.108</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.109
			<timestamp>Apr 25 19:19:52 2026</timestamp>
			<uuid>{1fdbecee-71a1-46e7-83da-d6fb2b8610fd}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.109</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.109</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.110
			<timestamp>Apr 25 19:20:23 2026</timestamp>
			<uuid>{78aef4ff-5189-4d12-b869-082d88a1d2e0}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.110</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.110</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.111
			<timestamp>Apr 25 19:21:05 2026</timestamp>
			<uuid>{3c6e3503-865e-4e9e-8804-453d4d8dfdef}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.111</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.111</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.112
			<timestamp>Apr 25 19:21:37 2026</timestamp>
			<uuid>{181a1773-e636-421f-baef-46c67f9d0f93}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.112</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.112</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.113
			<timestamp>Apr 25 19:26:30 2026</timestamp>
			<uuid>{cf86ee76-5d4a-4e1b-b9fb-8f968236985c}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.113</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.113</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.114
			<timestamp>Apr 25 19:33:37 2026</timestamp>
			<uuid>{e07a6e1e-5ed4-4eea-adb7-a49d4156ef8b}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.114</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.114</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.115
			<timestamp>Apr 25 19:35:16 2026</timestamp>
			<uuid>{7ca10d19-c30f-4bc3-9914-835413b99b03}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.115</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.115</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.116
			<timestamp>Apr 25 19:37:57 2026</timestamp>
			<uuid>{1edd629b-4451-40c2-87d7-da76ce6d6a9f}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.116</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.116</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.117
			<timestamp>Apr 25 19:39:07 2026</timestamp>
			<uuid>{38136abb-1d8b-48e9-a82f-c379329faea4}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.117</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.117</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.118
			<timestamp>Apr 25 19:41:26 2026</timestamp>
			<uuid>{22321204-2c90-4631-89ed-16db40c24b30}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.118</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.118</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.119
			<timestamp>Apr 25 19:42:26 2026</timestamp>
			<uuid>{09ab92d7-6552-4f75-a2b2-b412f307e542}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.119</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.119</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.120
			<timestamp>Apr 25 19:43:47 2026</timestamp>
			<uuid>{b4733570-1e81-466e-adf9-0676b5700eee}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.120</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.120</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.121
			<timestamp>Apr 25 19:44:41 2026</timestamp>
			<uuid>{baf0f98a-9200-4844-b809-b68db78cd5b0}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.121</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.121</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.122
			<timestamp>Apr 25 19:53:21 2026</timestamp>
			<uuid>{22127b1e-8ddd-4f4f-af58-3a7a782f83e1}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.122</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.122</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.123
			<timestamp>Apr 25 21:38:38 2026</timestamp>
			<uuid>{06e1f85d-5707-413c-8559-86dec2d963b3}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.123</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.123</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.124
			<timestamp>Apr 25 21:41:01 2026</timestamp>
			<uuid>{c1975bbb-acd9-474a-a3bb-9631639aaa91}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.124</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.124</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.125
			<timestamp>Apr 25 21:42:51 2026</timestamp>
			<uuid>{b83fb390-31ba-47cb-bc64-097d3f44d638}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.125</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.125</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.126
			<timestamp>Apr 25 21:45:06 2026</timestamp>
			<uuid>{ee7607ef-662f-473c-9cf4-a012c6bff9fa}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.126</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.126</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.127
			<timestamp>Apr 25 21:51:21 2026</timestamp>
			<uuid>{70bffb3c-c419-476b-acbc-33ff5cafb2f3}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.127</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.127</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.128
			<timestamp>Apr 25 21:53:38 2026</timestamp>
			<uuid>{ded8ea27-c616-4ac9-9de6-533e395b323f}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.128</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.128</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.129
			<timestamp>Apr 25 21:54:43 2026</timestamp>
			<uuid>{c4fe988a-3651-42c9-a85d-5f703cf2add0}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.129</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.129</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.130
			<timestamp>Apr 25 21:55:17 2026</timestamp>
			<uuid>{5fdd673a-eb1f-44e3-8f55-94c70a32376f}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.130</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.130</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.131
			<timestamp>Apr 25 21:56:05 2026</timestamp>
			<uuid>{88e84000-1d03-4c84-a036-bd2ac0d47b29}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.131</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.131</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.132
			<timestamp>Apr 25 21:56:39 2026</timestamp>
			<uuid>{8b01892f-58db-42d6-b492-7735399fb82b}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.132</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.132</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.133
			<timestamp>Apr 25 21:59:17 2026</timestamp>
			<uuid>{ba0121b7-26ae-4bdd-a500-83a94afcfd94}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.133</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.133</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.134
			<timestamp>Apr 25 22:01:10 2026</timestamp>
			<uuid>{83110d8a-f11a-4536-b508-300cc216dd45}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.134</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.134</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.135
			<timestamp>Apr 25 22:06:28 2026</timestamp>
			<uuid>{072bbd0e-3976-427b-9e86-4adec528f81f}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.135</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.135</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.136
			<timestamp>Apr 25 22:07:51 2026</timestamp>
			<uuid>{924ecb4c-4d75-460f-8083-ccd66be66216}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.136</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.136</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.137
			<timestamp>Apr 25 22:11:52 2026</timestamp>
			<uuid>{d5d396eb-7e65-4857-bb20-341f844b3c97}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.137</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.137</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.138
			<timestamp>Apr 26 18:57:42 2026</timestamp>
			<uuid>{50346418-64d9-45c2-b9c2-8ba3c93647e7}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.138</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.138</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.139
			<timestamp>Apr 26 19:00:44 2026</timestamp>
			<uuid>{f45db7d2-118b-45ea-9bc5-0afcc6d3adba}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.139</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.139</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.140
			<timestamp>Apr 26 19:04:36 2026</timestamp>
			<uuid>{7cacc0a6-6951-4b66-b6f1-0ddbcb6f1bd2}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.140</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.140</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.141
			<timestamp>Apr 26 19:05:49 2026</timestamp>
			<uuid>{a1f50026-39c7-4460-84b4-fa5f091b73ec}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.141</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.141</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.142
			<timestamp>Apr 26 19:06:56 2026</timestamp>
			<uuid>{45fc49a0-cc25-4ace-b8d8-fe2f823ecdfd}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.142</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.142</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.143
			<timestamp>Apr 26 19:08:24 2026</timestamp>
			<uuid>{3ae7e663-6e74-4777-9d6c-f5ec10dc4f62}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.143</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.143</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.144
			<timestamp>Apr 26 19:13:39 2026</timestamp>
			<uuid>{7edba48f-19bf-414c-b48b-5f2326a24eab}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.144</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.144</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.145
			<timestamp>Apr 26 19:14:42 2026</timestamp>
			<uuid>{a4184248-80fe-48c8-95d3-ac4f37cc98af}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.145</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.145</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.146
			<timestamp>Apr 26 19:15:27 2026</timestamp>
			<uuid>{539f0c34-dcaf-40d5-9aba-fcc8be19414d}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.146</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.146</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.147
			<timestamp>Apr 26 19:16:23 2026</timestamp>
			<uuid>{aed00c2d-b45c-4357-9ac1-8e205ede33a3}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.147</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.147</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.148
			<timestamp>Apr 26 19:17:34 2026</timestamp>
			<uuid>{19035c00-41ec-4e86-8275-225de051d537}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.148</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.148</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.149
			<timestamp>Apr 26 19:20:25 2026</timestamp>
			<uuid>{512ff9c0-d2ca-483d-9ee4-b3e5853d8876}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.149</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.149</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.150
			<timestamp>Apr 26 19:21:12 2026</timestamp>
			<uuid>{dc545012-5ef3-4ba3-b227-0c3dafb41b94}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.150</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.150</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.151
			<timestamp>Apr 26 20:45:42 2026</timestamp>
			<uuid>{27b69a25-1c62-4ce6-9d4d-01968846cf2d}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.151</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.151</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.152
			<timestamp>Apr 26 20:46:36 2026</timestamp>
			<uuid>{11dd02a9-7cc8-4bd3-9dd1-bef42f0ce033}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.152</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.152</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.153
			<timestamp>Apr 26 20:47:31 2026</timestamp>
			<uuid>{8d0f9184-6ecf-4004-a4b1-8bf36a7889c5}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.153</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.153</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.154
			<timestamp>Apr 26 20:48:12 2026</timestamp>
			<uuid>{eac97549-5eb3-416d-b325-295d29d55dce}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.154</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.154</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.155
			<timestamp>Apr 26 20:49:26 2026</timestamp>
			<uuid>{e3283f28-4820-4c16-93a7-ac3c684119ab}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.155</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.155</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.156
			<timestamp>Apr 26 20:51:34 2026</timestamp>
			<uuid>{d7abef07-da52-4667-859b-372eb7b14c08}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.156</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.156</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.157
			<timestamp>Apr 26 20:52:28 2026</timestamp>
			<uuid>{dcdedb8b-55a8-44d3-b82a-0467e10795c8}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.157</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.157</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.158
			<timestamp>Apr 26 20:54:44 2026</timestamp>
			<uuid>{68d90313-fcb6-417e-9087-5f3b5e629961}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.158</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.158</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.159
			<timestamp>Apr 26 20:57:48 2026</timestamp>
			<uuid>{150cb568-4177-4f7e-af6d-886f7a9758ca}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.159</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.159</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.160
			<timestamp>Apr 26 20:59:43 2026</timestamp>
			<uuid>{9bdd1a67-9542-4487-a4f8-3a7191b2192d}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.160</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.160</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.161
			<timestamp>Apr 26 21:00:33 2026</timestamp>
			<uuid>{e8cc9e88-56ed-453d-bc42-ac7fed68fb4b}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.161</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.161</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.162
			<timestamp>Apr 26 21:02:52 2026</timestamp>
			<uuid>{e14dffc5-cd84-4110-b866-be3a32ee77a7}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.162</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.162</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.163
			<timestamp>Apr 26 21:03:30 2026</timestamp>
			<uuid>{f85028f7-69ca-45e8-969e-b60a2d3f367a}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.163</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.163</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.164
			<timestamp>Apr 26 21:05:45 2026</timestamp>
			<uuid>{bd858238-baa7-4726-a858-3d4de7352d9e}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.164</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.164</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.165
			<timestamp>Apr 26 21:06:45 2026</timestamp>
			<uuid>{ea21ff4c-47d4-4c54-9ef4-0b1b6a4f7e51}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.165</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.165</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.166
			<timestamp>Apr 26 21:07:33 2026</timestamp>
			<uuid>{52f3e6e2-4e2d-4094-b4a9-5065d06d64af}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.166</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.166</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.167
			<timestamp>Apr 26 21:09:02 2026</timestamp>
			<uuid>{c3c7933e-8158-4bea-98cf-e5762960849f}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.167</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.167</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.168
			<timestamp>Apr 26 21:09:45 2026</timestamp>
			<uuid>{12123523-49bb-45c4-bbb0-e3cd6331a8a1}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.168</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.168</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.169
			<timestamp>Apr 26 21:10:25 2026</timestamp>
			<uuid>{fc111768-7baf-469c-b6d3-b96e031f8b65}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.169</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.169</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.170
			<timestamp>Apr 26 21:10:54 2026</timestamp>
			<uuid>{f60b9ac4-7bd1-402d-942b-8c72ec322d85}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.170</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.170</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.171
			<timestamp>Apr 26 21:11:48 2026</timestamp>
			<uuid>{60665539-abf7-4e5a-b7c5-1ab7d36b7ff1}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.171</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.171</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.172
			<timestamp>Apr 26 21:13:04 2026</timestamp>
			<uuid>{4550fc40-ac2d-487e-a906-484892b73481}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.172</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.172</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.173
			<timestamp>Apr 26 21:14:55 2026</timestamp>
			<uuid>{3792ca59-893d-4487-b372-76c499424b3f}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.173</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.173</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.174
			<timestamp>Apr 26 21:17:41 2026</timestamp>
			<uuid>{81358c33-a50b-47b7-a400-b4099ea14623}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.174</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.174</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.175
			<timestamp>Apr 26 21:21:41 2026</timestamp>
			<uuid>{d1c33425-cd53-47be-9fec-eaf94cc4907a}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.175</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.175</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.176
			<timestamp>Apr 26 21:23:57 2026</timestamp>
			<uuid>{fc644d02-74b6-49b6-9d03-6dc8dee2f4df}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.176</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.176</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.177
			<timestamp>Apr 26 21:25:13 2026</timestamp>
			<uuid>{abd4645e-459a-4a67-bb4a-3598908df94f}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.177</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.177</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.178
			<timestamp>Apr 26 21:26:21 2026</timestamp>
			<uuid>{5789c4b3-48f3-4811-b817-f8b221098ef2}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.178</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.178</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.179
			<timestamp>Apr 26 21:27:39 2026</timestamp>
			<uuid>{efba918b-23db-4aed-aad3-ff87f9cc4723}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.179</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.179</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.180
			<timestamp>Apr 26 21:29:16 2026</timestamp>
			<uuid>{9f536b89-6640-47b2-9615-8ecc03092f83}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.180</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.180</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.181
			<timestamp>Apr 26 21:30:40 2026</timestamp>
			<uuid>{a75d8acc-07c1-4bbc-a731-6a8c3d6c90ae}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.181</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.181</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.182
			<timestamp>Apr 26 21:32:41 2026</timestamp>
			<uuid>{aa878676-f82b-444e-8537-748dba0c7f32}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.182</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.182</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.183
			<timestamp>Apr 26 21:32:59 2026</timestamp>
			<uuid>{818e6553-4b21-491b-80aa-4c6b4e99ff7d}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.183</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.183</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.184
			<timestamp>Apr 26 21:34:14 2026</timestamp>
			<uuid>{f99e9cc5-5fe0-4140-8034-ba7c7aea4c4a}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.184</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.184</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.185
			<timestamp>Apr 26 21:35:32 2026</timestamp>
			<uuid>{dc37feb6-34bb-48f5-be9a-ae3aace235ca}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.185</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.185</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.186
			<timestamp>Apr 26 21:36:26 2026</timestamp>
			<uuid>{b0ef6a0c-f147-4d58-95e5-49ac6a7d7ea1}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.186</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.186</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.187
			<timestamp>Apr 26 21:37:27 2026</timestamp>
			<uuid>{23e5ce20-3d57-402e-ac93-96363c524668}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.187</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.187</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.188
			<timestamp>Apr 26 21:43:11 2026</timestamp>
			<uuid>{6c9e8e32-388d-4adc-8507-15a8415a6c0d}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.188</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.188</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.189
			<timestamp>Apr 26 21:45:35 2026</timestamp>
			<uuid>{492bec89-6030-4c80-814e-ca816998de51}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.189</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.189</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.190
			<timestamp>Apr 26 21:46:49 2026</timestamp>
			<uuid>{0ff28f14-7a6c-4d3d-9525-0c23fe7612a3}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.190</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.190</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.191
			<timestamp>Apr 26 21:47:20 2026</timestamp>
			<uuid>{e5533835-7431-4e5f-baf0-b258cc11d649}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.191</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.191</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.192
			<timestamp>Apr 26 21:49:43 2026</timestamp>
			<uuid>{306daf2f-7eb2-4c2e-a1e2-c6a9ec99df39}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.192</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.192</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.193
			<timestamp>Apr 26 21:50:48 2026</timestamp>
			<uuid>{b9a15573-9555-42ab-be05-ad222efe959e}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.193</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.193</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.194
			<timestamp>Apr 26 21:52:36 2026</timestamp>
			<uuid>{b4bc3caf-7af2-4064-a8aa-237dc22d8f7b}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.194</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.194</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.195
			<timestamp>Apr 26 21:54:12 2026</timestamp>
			<uuid>{0866fe6c-5047-469c-b3bb-a384f9483a8e}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.195</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.195</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.196
			<timestamp>Apr 26 21:55:02 2026</timestamp>
			<uuid>{958158d1-cb41-435a-8322-5f59a72886f5}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.196</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.196</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.197
			<timestamp>Apr 26 21:56:42 2026</timestamp>
			<uuid>{14994ae1-0627-4b15-90c5-80bc05f0043a}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.197</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.197</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.198
			<timestamp>Apr 26 21:57:44 2026</timestamp>
			<uuid>{577701bb-6b23-4097-9bc7-96de6a331df4}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.198</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.198</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.199
			<timestamp>Apr 26 21:58:50 2026</timestamp>
			<uuid>{6ce520c2-8d22-4bf4-9611-dc08d6b001d5}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.199</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.199</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.200
			<timestamp>Apr 26 21:59:56 2026</timestamp>
			<uuid>{30ba25b7-7a4b-4f39-904e-857ae960ceee}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.200</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.200</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.201
			<timestamp>Apr 26 22:01:07 2026</timestamp>
			<uuid>{268ed10e-383e-4557-b956-71336de2a7c7}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.201</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.201</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.202
			<timestamp>Apr 26 22:02:10 2026</timestamp>
			<uuid>{b7abcf1b-466e-4e11-802f-6b07ac3fdff2}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.202</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.202</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.203
			<timestamp>Apr 26 22:05:11 2026</timestamp>
			<uuid>{6960ec0a-b49e-4b94-b073-d7cbb09032cc}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.203</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.203</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.204
			<timestamp>Apr 26 22:06:18 2026</timestamp>
			<uuid>{ecf1e48c-f16b-4bcc-9a0f-48ca82b8533f}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.204</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.204</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.205
			<timestamp>Apr 26 22:10:16 2026</timestamp>
			<uuid>{a02d53ec-b818-4535-814f-c44d813c08d5}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.205</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.205</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.206
			<timestamp>Apr 26 22:11:21 2026</timestamp>
			<uuid>{04f7298b-6064-4005-a130-2b5a3c13e08c}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.206</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.206</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.207
			<timestamp>Apr 26 22:12:38 2026</timestamp>
			<uuid>{9c4637ed-c45c-45d7-9dc9-52dd3a5d901b}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.207</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.207</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.208
			<timestamp>Apr 26 22:13:57 2026</timestamp>
			<uuid>{16646b6f-b25d-4123-b602-1670aaa315df}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.208</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.208</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.209
			<timestamp>Apr 26 22:15:03 2026</timestamp>
			<uuid>{c9255c91-f8e9-4070-8977-f5a0ae7ba48f}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.209</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.209</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.210
			<timestamp>Apr 26 22:16:09 2026</timestamp>
			<uuid>{6b38017f-c8cb-4b92-95c5-ddc298f1cf24}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.210</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.210</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.211
			<timestamp>Apr 26 22:17:49 2026</timestamp>
			<uuid>{82ec12f0-2726-4c6a-989e-961d8f4e6afe}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.211</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.211</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.212
			<timestamp>Apr 26 22:19:29 2026</timestamp>
			<uuid>{76e0f0f6-0aa2-4e81-8f9a-0e893942372b}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.212</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.212</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.213
			<timestamp>Apr 26 22:21:08 2026</timestamp>
			<uuid>{d418e243-ba6a-4eec-8876-630eb00344e0}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.213</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.213</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.214
			<timestamp>Apr 26 22:22:00 2026</timestamp>
			<uuid>{1bb84b29-8f3a-4cd9-a328-a87e09911149}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.214</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.214</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.215
			<timestamp>Apr 26 22:23:17 2026</timestamp>
			<uuid>{a23bdfa5-264d-4e97-988d-47578f1d8de9}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.215</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.215</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.216
			<timestamp>Apr 26 22:24:17 2026</timestamp>
			<uuid>{4b1ebafb-da17-4394-b96b-4e0ed196278e}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.216</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.216</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.217
			<timestamp>Apr 26 22:25:34 2026</timestamp>
			<uuid>{1c8b7d6d-8ede-434f-8a21-c649097b0d7d}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.217</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.217</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.218
			<timestamp>Apr 26 22:26:56 2026</timestamp>
			<uuid>{3d0e3e1a-14fe-4e9f-b892-792110aba3cc}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.218</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.218</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.219
			<timestamp>Apr 26 22:27:51 2026</timestamp>
			<uuid>{d6415f24-8690-40de-ac9a-d0e0ac09d97e}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.219</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.219</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.220
			<timestamp>Apr 26 22:28:08 2026</timestamp>
			<uuid>{306d35f4-0a4d-493d-95e9-469b726072d0}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.220</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.220</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.221
			<timestamp>Apr 26 22:29:18 2026</timestamp>
			<uuid>{ada68366-47b5-40a5-a780-282afe4e9d0b}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.221</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.221</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.222
			<timestamp>Apr 26 22:30:10 2026</timestamp>
			<uuid>{13e83b31-896b-41e0-925b-f3ef2d88233d}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.222</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.222</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.223
			<timestamp>Apr 26 22:31:19 2026</timestamp>
			<uuid>{269b18dc-9e44-4576-904f-e524022268d6}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.223</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.223</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.224
			<timestamp>Apr 26 22:33:18 2026</timestamp>
			<uuid>{4cbf9a51-c2cb-416b-9081-ba00e9115415}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.224</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.224</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.225
			<timestamp>Apr 26 22:34:34 2026</timestamp>
			<uuid>{e744dd14-dbed-4433-9976-3f8188a6cd63}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.225</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.225</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.226
			<timestamp>Apr 26 22:36:31 2026</timestamp>
			<uuid>{bb21fa26-ccb0-4434-83a9-787c9f130208}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.226</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.226</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.227
			<timestamp>Apr 26 22:37:00 2026</timestamp>
			<uuid>{f15340e9-7e66-467e-897c-7a49396d249e}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.227</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.227</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.228
			<timestamp>Apr 26 22:41:42 2026</timestamp>
			<uuid>{48b64f94-3c38-400a-959b-10f834520581}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.228</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.228</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.229
			<timestamp>Apr 26 22:42:52 2026</timestamp>
			<uuid>{c4740c84-4474-49b8-b18b-c7c520ad88c7}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.229</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.229</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.230
			<timestamp>Apr 26 22:44:14 2026</timestamp>
			<uuid>{f4f67b10-5ed6-4cd4-9aeb-6360e715ec1e}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.230</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.230</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.231
			<timestamp>Apr 26 22:45:26 2026</timestamp>
			<uuid>{3b20d72b-fb4f-4990-a55a-e99d9153a7c3}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.231</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.231</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.232
			<timestamp>Apr 26 22:49:13 2026</timestamp>
			<uuid>{05f0be5e-f071-4eb5-b341-06efcea0e231}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.232</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.232</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.233
			<timestamp>Apr 26 23:07:25 2026</timestamp>
			<uuid>{0c5a6dd9-860b-422b-bc17-48b435b9ee4a}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.233</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.233</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.234
			<timestamp>Apr 26 23:11:36 2026</timestamp>
			<uuid>{469b7247-5f27-40ce-9d06-e0cf45352178}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.234</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.234</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.235
			<timestamp>Apr 26 23:16:32 2026</timestamp>
			<uuid>{3d858c55-8905-464e-b2f4-fbf13a56095b}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.235</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.235</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.236
			<timestamp>Apr 26 23:28:08 2026</timestamp>
			<uuid>{3171a52d-ccac-4f81-a4ae-961efff759fa}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.236</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.236</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.237
			<timestamp>Apr 26 23:30:04 2026</timestamp>
			<uuid>{bf85a2d9-7c0e-4223-9204-e2f196ca1929}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.237</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.237</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.238
			<timestamp>May 13 12:46:57 2026</timestamp>
			<uuid>{71a9be07-c4f8-42dd-8bba-d0bd7746217d}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.238</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.238</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.239
			<timestamp>May 13 17:59:32 2026</timestamp>
			<uuid>{84abbc4f-8fe1-4040-814a-66c9316035f8}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.239</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.239</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.240
			<timestamp>May 13 18:01:04 2026</timestamp>
			<uuid>{04c63705-5148-48ac-96d0-4e3ef0477954}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/ns25z205/cadence/EE6320_2026/ee6320_2026/03_1_VCO/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.240</psfdir>
			<simdir>/home/ns25z205/simulation/results/maestro/ExplorerRun.240</simdir>
		</historyentry>
	</history>
</setupdb>
